# Keil uVision project ADCT0ATrigger.uvproj, settings and files
target ADCT0ATrigger (ARM-ADS)
  device: LM3S1968 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: ADCT0ATrigger
  c flags: Optim=1
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Code
    ./: Startup.s ADCT0ATrigger.c ADCTestmain.c fixed.c ADCT0ATrigger.h PLL.c SysTick.c temperature.c rit128x96x4.c
  group library
    ../driverlib/rvmdk/: driverlib.lib
