# Keil uVision project PeriodicTimer0AInts.uvproj, settings and files
target PeriodicTimer0AInts (ARM-ADS)
  device: LM3S1968 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: PeriodicTimer0AInts
  c flags: Optim=1
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Code
    ./: Startup.s Timer0A.c Lab5Driver.c DAC.c Switch.c Music.c DAC.h Music.h Switch.h Timer0A.h Globals.h graphic.c PeriodicTimer0AInts.c sed1335.c SED1335-STM32.c GameDraw.h graphic.h LCDDriver.h sed1335.h XBeeIn.h
  group Library
    ../driverlib/rvmdk/: driverlib.lib
