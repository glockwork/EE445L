# Keil uVision project Final811.uvproj, settings and files
target Switch (ARM-ADS)
  device: LM3S811 Luminary Micro
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0xFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Switch
  c flags: Optim=1
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Code
    ./: Startup.s SysTick.c SysTick.h XBeeOut.h XbeeOut.c UART2.c UART2.h UART2TestMain.c FIFO.h globals.c globals.h Output.c PLL.c rit128x96x4.c PCUART2.c
  group Library
    ../driverlib/rvmdk/: driverlib.lib
