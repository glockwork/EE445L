# Keil uVision project PeriodicTimer0AInts.uvproj, settings and files
target PeriodicTimer0AInts (ARM-ADS)
  device: LM3S1968 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: PeriodicTimer0AInts
  c flags: Optim=1
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Code
    ./: Startup.s Timer0A.c DAC.c Switch.c Music.c DAC.h Music.h Switch.h Timer0A.h Globals.h OLEDdraw.c Output.c rit128x96x4.c OLEDdraw.h Output.h rit128x96x4.h FinalProjectDriver.c UART2.c Xbee.c SysTick.c
  group Library
    ../driverlib/rvmdk/: driverlib.lib
