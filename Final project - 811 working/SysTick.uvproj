# Keil uVision project SysTick.uvproj, settings and files
target SysTick (ARM-ADS)
  device: LM3S811 Luminary Micro
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0xFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SysTick
  c flags: Optim=1
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Code
    ./: Startup.s SysTick.c Globals.c GPIO.c Switch.c Timer0A.c UART2.c XbeeOut.c PLL.c
    ../driverlib/rvmdk/: driverlib.lib
