# Keil uVision project GPIO.uvproj, settings and files
target GPIO (ARM-ADS)
  device: LM3S811 Luminary Micro
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0xFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: GPIO
  c flags: Optim=1
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Code
    ./: Startup.s GPIO.c Globals.c SysTick.c UART2.c XbeeOut.c PLL.c Switch.c Timer0A.c
    ../driverlib/rvmdk/: driverlib.lib
