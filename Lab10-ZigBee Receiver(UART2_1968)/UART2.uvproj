# Keil uVision project UART2.uvproj, settings and files
target UART2 (ARM-ADS)
  device: LM3S1968 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: UART2
  c flags: Optim=1
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Code
    ./: Startup.s UART2.c UART2TestMain.c fixed.c Output.c rit128x96x4.c Xbee.c SysTick.c
  group Library
    ../driverlib/rvmdk/: driverlib.lib
