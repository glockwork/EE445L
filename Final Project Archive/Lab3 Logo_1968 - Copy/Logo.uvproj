# Keil uVision project Logo.uvproj, settings and files
target Logo (ARM-ADS)
  device: LM3S1968 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: Logo
  c flags: Optim=1
  c include: ..;..\..\..;..\inc;..\driverlib\rvmdk;..\driverlib
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Sources
    ./: Startup.s rit128x96x4.c logo.c PLL.c SysTick.c SysTick.h Output.c Buttons.c helper.c OLED.c OLEDdraw.c Speakers.c Sound.c PWM.c clockmain.c PWM.h OLEDdraw.h
  group Library
    ../driverlib/rvmdk/: driverlib.lib
